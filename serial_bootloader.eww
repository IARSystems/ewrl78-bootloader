<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\rl78-boot\rl78-boot.ewp</path>
    </project>
    <batchBuild />
</workspace>
